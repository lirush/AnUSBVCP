# Keil uVision project AnalogINtoUCBVCP.uvprojx, settings and files
target AnINtoUSBVCP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.51
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AnalogINtoUCBVCP +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\lib\inc\cmsis;.\lib\inc\MDR32F9Qx;.\lib\inc\MDR32F9Qx\USB_Library;.\main;.\app\vcp;.\app\ansensors;.\config;.\system;.\icpanibul;.\queue;.\chips\ad7610;.\chips\adg439;.\spi;.\icpanibul;.\utility
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group lib
    ./lib/src/cmsis/: system_MDR32F9Qx.c startup_MDR32F9Qx.s
  group main
    ./main/: main.c
  group vcp
    ./app/vcp/: VCom_Config.c
  group chips
    ./chips/adg439/: adg439.c
    ./chips/ad7610/: ad7610.c
  group drivers
    ./lib/src/MDR32F9Qx/: MDR32F9Qx_eeprom.c MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c MDR32F9Qx_ssp.c MDR32F9Qx_timer.c MDR32F9Qx_usb.c
    ./lib/src/MDR32F9Qx/USB_Library/: MDR32F9Qx_usb_CDC.c MDR32F9Qx_usb_device.c
  group sys
    ./system/: systick.c
  group icpanibul
    ./icpanibul/: icpanibul.c
  group queue
    ./queue/: ringqueue.c
  group spi
    ./spi/: spi.c
  group utility
    ./utility/: utility.c
